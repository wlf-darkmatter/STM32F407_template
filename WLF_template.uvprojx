# Keil uVision project WLF_template.uvprojx, settings and files
target wlf (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WLF_template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\HardWare;.\USER;.\SYSTEM;.\Font;.\USMART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HardWare
    ./HardWare/: Beep.c Key_STM32F407ZET6.c LED_STM32F407ZET6.c OLED.c PWM.c TFT_LCD.c Tim.c WIFI_ESP8266.c
  group Core
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c wlf_I2C.c stm32f4xx_syscfg.c stm32f4xx_sdio.c
  group SYSTEM
    ./SYSTEM/: delay.c sys.c usart.c
  group USMART
    ./USMART/: usmart.c usmart_str.c usmart_config.c
